# Keil uVision project Template.uvprojx, settings and files
target Template (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.4
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\USER;..\STM32F10x_FWLIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARK\CONTROL;..\HARDWARK\DMP;..\HARDWARK\filter;..\HARDWARK\IIC;..\HARDWARK\MPU6050;..\HARDWARK\TIMER;..\HARDWARK\PWM;..\HARDWARK\DIANJI;..\HARDWARK\ENCODER;..\HARDWARK\OLED;..\HARDWARK\hwjs;..\HARDWARK\show;..\HARDWARK\KEY
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLIB
    ../STM32F10x_FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARK
    ../HARDWARK/CONTROL/: control.c
    ../HARDWARK/filter/: filter.c
    ../HARDWARK/IIC/: IOI2C.c
    ../HARDWARK/MPU6050/: MPU6050.c
    ../HARDWARK/TIMER/: timer.c
    ../HARDWARK/PWM/: pwm.c
    ../HARDWARK/DIANJI/: dianji.c
    ../HARDWARK/DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../HARDWARK/ENCODER/: encoder.c
    ../HARDWARK/OLED/: oled.c
    ../HARDWARK/hwjs/: hwjs.c
    ../HARDWARK/show/: show.c
    ../HARDWARK/KEY/: key.c
